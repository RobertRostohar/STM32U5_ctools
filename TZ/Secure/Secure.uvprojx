# Keil uVision project Secure.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.0-dev0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\RTE\Device\STM32U585AIIx\stm32u585xx_flash_s.sct
  group :STM32CubeMX_S:Common Sources
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure/Src/: main.c stm32u5xx_it.c secure_nsc.c
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure/Inc/: stm32u5xx_it.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure_nsclib/: secure_nsc.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/: STM32CubeMX.ioc
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:Flash 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:GTZC 1.2.0, Device:STM32Cube HAL:I2C 1.2.0, Device:STM32Cube HAL:ICACHE 1.2.0, Device:STM32Cube HAL:MDF 1.2.0, Device:STM32Cube HAL:OSPI 1.2.0, Device:STM32Cube HAL:PCD 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:SPI 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:STM32Cube LL:Common 1.2.0, Device:STM32Cube LL:DLYB 1.2.0, Device:STM32Cube LL:GPIO 1.2.0, Device:STM32Cube LL:PWR 1.2.0, Device:STM32Cube LL:RCC 1.2.0, Device:STM32Cube LL:UCPD 1.2.0, Device:STM32Cube LL:UTILS 1.2.0, Device:Startup 1.0.0
