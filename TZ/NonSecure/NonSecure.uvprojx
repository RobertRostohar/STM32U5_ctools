# Keil uVision project NonSecure.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\RTE\Device\STM32U585AIIx\stm32u585xx_flash_ns.sct
  group Source Group 1
    ../Secure/Objects/: test_CMSE_Lib.o
  group :STM32CubeMX_NS:Common Sources
    ../Board/B-U585I-IOT02A/STM32CubeMX/NonSecure/Src/: main.c stm32u5xx_it.c
    ../Board/B-U585I-IOT02A/STM32CubeMX/NonSecure/Inc/: stm32u5xx_it.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure_nsclib/: secure_nsc.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/: STM32CubeMX.ioc
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:Flash 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:GTZC 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:Startup 1.0.0
